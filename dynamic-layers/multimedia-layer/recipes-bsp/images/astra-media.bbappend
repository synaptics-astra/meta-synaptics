IMAGE_INSTALL:append = " \
    gstreamer1.0-plugins-bad-fdkaac \
    gstreamer1.0-plugins-base-opus \
    gstreamer1.0-plugins-good-wavenc \
    gstreamer1.0-plugins-ugly-a52dec \
"
