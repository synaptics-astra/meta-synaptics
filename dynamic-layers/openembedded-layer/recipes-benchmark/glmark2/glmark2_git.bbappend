FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-devpath-for-DRM-device.patch"
SRC_URI += "file://0002-Enable-Triplebuffering-for-DRM.patch"
