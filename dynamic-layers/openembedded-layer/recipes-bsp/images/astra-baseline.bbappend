IMAGE_INSTALL:append:dolphin = "openssl cpp-netlib jsoncpp libtinyxml2"
