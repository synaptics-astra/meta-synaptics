TOOLCHAIN_TARGET_TASK:append = " lib32-libtinyxml2-dev lib32-cpp-netlib-dev"
TOOLCHAIN_TARGET_TASK:append = " lib32-jsoncpp-staticdev"
