# Configuring the features required in each module of QT Packages
PACKAGECONFIG:remove = ' wayland-vulkan-server-buffer '
