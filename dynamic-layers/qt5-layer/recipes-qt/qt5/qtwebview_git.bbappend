# Configuring the features required in each module of QT Packages
PACKAGECONFIG:append:pn-qtwebview = ' examples '
