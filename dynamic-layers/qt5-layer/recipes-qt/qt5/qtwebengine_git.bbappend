# Configuring the features required in each module of QT Packages
PACKAGECONFIG:append:pn-qtwebengine = ' webrtc proprietary-codecs glib zlib spellchecker examples '
