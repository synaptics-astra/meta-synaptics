FILESEXTRAPATHS:prepend := "${THISDIR}/${BP}:"

SRC_URI:append = " file://factory_setting_mac.patch"
