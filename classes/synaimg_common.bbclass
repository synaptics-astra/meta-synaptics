#/*******************************************************************************
#*
#*             Copyright 2020, Beechwoods Software, Inc.
#*
#*******************************************************************************/

SYNAIMG_DEPLOY_SUBDIR ?= "SYNAIMG"
SYNAIMG_EMMC_DEVICE ?= "mmcblk0"

