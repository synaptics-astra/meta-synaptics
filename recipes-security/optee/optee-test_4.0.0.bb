require optee-test.inc

SRCREV = "1c3d6be5eaa6174e3dbabf60928d15628e39b994"

