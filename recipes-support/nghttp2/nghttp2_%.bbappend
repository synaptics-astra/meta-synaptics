ALLOW_EMPTY:${PN}-client = "1"
ALLOW_EMPTY:${PN}-server = "1"
